require linux-yocto-amd-x86.inc

KBRANCH:amd-x86  = "v6.12/standard/x86"
