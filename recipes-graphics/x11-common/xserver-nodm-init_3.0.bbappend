FILESEXTRAPATHS:prepend:amd-x86 := "${THISDIR}/${PN}:"
